# Keil uVision project 电梯驱动.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 电梯驱动 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\电梯驱动;.\App;.\Hardwaer
  group 源组 1
    ./: STARTUP.A51 main.c
  group App
    ./App/: Usart.c Delay_time.c
  group Hardware
    ./Hardwaer/: Door_INIT.c Floor_INIT.c Key_INIT.c Motor_INIT.c Person_Check.c
